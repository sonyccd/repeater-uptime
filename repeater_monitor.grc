options:
  parameters:
    author: Claude Code
    generate_options: qt_gui
    id: repeater_monitor
    output_language: python
    title: FM Repeater Uptime Monitor
  states: {}

blocks:
- name: activity_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Activity Threshold (dB)
    orient: Qt.Horizontal
    start: '-60'
    step: '1'
    stop: '0'
    value: '-30'
  states: {}
- name: audio_decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency (Hz)
    labelpos: top
    type: real
    value: 146.52e6
  states: {}
- name: cooldown_time
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: Cooldown Time (seconds)
    orient: Qt.Horizontal
    rangeType: int
    start: '10'
    step: '10'
    stop: '600'
    value: '60'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: uptime_kuma_url
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0,1,2
    label: Uptime Kuma URL
    labelpos: top
    type: string
    value: http://localhost:3001/api/push/example
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decimation
    quad_rate: samp_rate//8
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    alias: power_probe
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '75000'
    decim: '8'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '25000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"numchan=1"'
    bb_gain0: '20'
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: ''
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 4,0,4,2
    name: Frequency Display
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 8,0,1,2
    label1: Power Level (dB)
    max: '0'
    min: '-100'
    name: Signal Strength
    type: float
    unit1: dBFS
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.01'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import time
      import threading
      import requests
      from gnuradio import gr

      class repeater_uptime_monitor(gr.sync_block):
          """
          Activity detection and Uptime Kuma heartbeat block
          """
          def __init__(self, activity_threshold=-30, cooldown_time=60, uptime_kuma_url="http://localhost:3001/api/push/example"):
              gr.sync_block.__init__(self,
                  name="repeater_uptime_monitor",
                  in_sig=[np.float32],
                  out_sig=[])

              self.activity_threshold = activity_threshold
              self.cooldown_time = cooldown_time
              self.uptime_kuma_url = uptime_kuma_url
              self.last_heartbeat_time = 0
              self.activity_detected = False

              # Start monitoring thread
              self.monitoring = True
              self.monitor_thread = threading.Thread(target=self._monitor_loop, daemon=True)
              self.monitor_thread.start()

              print(f"Uptime Kuma Monitor initialized:")
              print(f"  Threshold: {activity_threshold} dBFS")
              print(f"  Cooldown: {cooldown_time} seconds")
              print(f"  URL: {uptime_kuma_url}")

          def work(self, input_items, output_items):
              # Get power level and convert to dB
              power_level = input_items[0][-1] if len(input_items[0]) > 0 else 0

              if power_level > 1e-10:
                  power_db = 10 * np.log10(power_level)
              else:
                  power_db = -100

              # Check for activity
              if power_db > self.activity_threshold:
                  if not self.activity_detected:
                      self.activity_detected = True
                      self._send_heartbeat()
                      print(f"Activity detected! Power: {power_db:.1f} dBFS")
              else:
                  self.activity_detected = False

              return len(input_items[0])

          def _monitor_loop(self):
              """Background monitoring loop"""
              while self.monitoring:
                  try:
                      time.sleep(1)  # Check every second
                  except:
                      break

          def _send_heartbeat(self):
              """Send heartbeat to Uptime Kuma"""
              current_time = time.time()

              # Check cooldown
              if current_time - self.last_heartbeat_time < self.cooldown_time:
                  return

              try:
                  response = requests.get(self.uptime_kuma_url, timeout=5)
                  if response.status_code == 200:
                      self.last_heartbeat_time = current_time
                      print(f"✓ Heartbeat sent at {time.strftime('%H:%M:%S')}")
                  else:
                      print(f"✗ Heartbeat failed: HTTP {response.status_code}")
              except Exception as e:
                  print(f"✗ Heartbeat error: {e}")

          def stop(self):
              self.monitoring = False
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', single_pole_iir_filter_xx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_probe_signal_x_0, '0']
- [single_pole_iir_filter_xx_0, '0', qtgui_number_sink_0, '0']
- [single_pole_iir_filter_xx_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
